## config/shields/Kconfig.defconfig
```kconfig
if SHIELD_MACROV1

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "X-boy V0.1"

endif
```
